# Keil uVision project bootloader.uvproj, settings and files
target dfu_single_bank_ble (s110) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: bootloader +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310, BOOTLOADER_BANKED BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\include;..\include\ble_transport;..\..\..\..\..\Include;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110
  memory RVCT4: ROM 0x3a000 size 0x6000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../../Source/templates/: system_nrf51.c
    ../: arm_startup_nrf51.s
  group Source Code
    ./../: main.c
    ../: dfu_single_bank.c bootloader.c bootloader_util_arm.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_dfu.c
  group Libraries
    ../../../../../Source/app_common/: app_timer.c app_scheduler.c app_gpiote.c crc16.c pstorage.c
    ../../../../../Source/sd_common/: softdevice_handler.c
  group HCI Transport
    ../../../../../Source/app_common/: hci_mem_pool.c
  group BLE Transport
    ../: dfu_transport_ble.c
    ../../../../../Source/ble/: ble_conn_params.c ble_advdata.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
